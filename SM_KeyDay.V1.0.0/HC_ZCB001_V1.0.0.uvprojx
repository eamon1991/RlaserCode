# Keil uVision project HC_ZCB001_V1.0.0.uvprojx, settings and files
target HC_ZCB001_V0.9 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HC_ZCB001_V3.01.hex +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRICER
  c include: .\CMSIS;.\FWlib\inc;.\FWlib\src;.\USER;.\HARDWARE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./USER/: main.c stm32f10x_it.c
  group Hardware
    ./HARDWARE/: tlc5620.c adc.c usart.c rtc.c exti.c timer.c delay.c power_convert.c ina.c flash.c usart2.c pvd.c
  group STARTCODE
    ./CMSIS/: startup_stm32f10x_hd.s
  group CMSIS
    ./CMSIS/: core_cm3.c
  group FWlib
    ./CMSIS/: system_stm32f10x.c
    ./FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_rtc.c
target HC_CB002_V1.0 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: yym0919-01 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRICER
  c include: ..\CMSIS;..\FWlib\inc;..\FWlib\src;..\USER;..\FWlib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
